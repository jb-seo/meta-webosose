EXTENDPRAUTO_append = "wand1"

# to set the Platform for EGL/eglvivante.h
OE_QMAKE_CXXFLAGS_append = " -DLINUX -DEGL_API_FB -DWL_EGL_PLATFORM"
